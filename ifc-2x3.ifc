Properties of the parts of a building model (IFC2X3)

# File
Description: Stellantrieb "Stella" 230 V NC für den automatischen hydraulischen Abgleich, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G8990010, Stellantrieb "Stella" 230 V NC für den automatischen hydraulischen Abgleich
In: Raum
Description: "Stella" - der intelligent autonome elektrothermische Stellantrieb 230 VAC NC für den automatischen adaptiven hydraulischen Abgleich der Heizkreise eines Heizkreisverteilers in Flächenheizungs- und Flächenkühlungssystemen. Sensoren an den Vor- und Rücklaufleitungen messen Temperaturunterschiede und ein Algorithmus berechnet fortlaufend die jeweils erforderliche Temperaturspreizung und die entsprechende Ventilstellung. Stromlos geschlossen und mit Klapphebel zum entlasteten Aufschrauben bzw. zum stromlosen manuellen Öffnen des Thermostatventils. Mit integrierter Vorlauftemperaturbegrenzung. Stella kann in Kombination mit allen gängigen Temperaturreglern und Klemmenleisten verwendet werden. Bei Verwendung von Geräten mit Schaltelement Triac ist eine Spannungsfestigkeit (V DRM) des Triacs von mindestens 800V erforderlich.; Classification: EC010193 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G8990010; ModelLabel: ZBOOA-010.185; GlobalTradeItemNumber: 4050528077417; ProductURL: https://alre.de/produkt_G8990010
Pset_Specification - NominalLength: 0.0742 m; NominalWidth: 0.0531 m; NominalDepth: 0.047 m; NetWeight: 0.093
Pset_ALRE_ETIM_Properties - Farbe: grau; Breite: 47; Ausführung: mit Wachs gefüllt; Funktion: spannungslos geschlossen (NC); Höhe: 74.2; Nennleistung: 1.7; Kabellänge: 1; Länge: 47; Umgebungstemperatur: 0; Schutzart (IP): IP54; Anschluss an Ventil: M30 x 1,5; Hublänge: 3.5; Netzspannung: 230 V AC; ETIM-Klasse: EC010193; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G8990010.pdf
